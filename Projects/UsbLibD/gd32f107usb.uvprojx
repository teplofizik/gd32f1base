# Keil uVision project gd32f107usb.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F107VC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gd32f107usb
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS, GD32F10X_CL
  c include: ..\..\GD32F10x_Firmware_Library\CMSIS;..\..\GD32F10x_Firmware_Library\CMSIS\GD\GD32F10x\Include;..\..\GD32F10x_Firmware_Library\GD32F10x_standard_peripheral\Include;..\..\EVAL_Library\Utilities;.\source;..\..\GD32F10x_Firmware_Library\GD32F10x_usbfs_library\driver\Include;..\..\GD32F10x_Firmware_Library\GD32F10x_usbfs_library\device\class\hid\Include;..\..\GD32F10x_Firmware_Library\GD32F10x_usbfs_library\device\core\Include;..\..\GD32F10x_Firmware_Library\GD32F10x_usbfs_library\ustd\class\hid;..\..\GD32F10x_Firmware_Library\GD32F10x_usbfs_library\ustd\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ./source/: gd32f10x_it.c main.c RTE_Components.h gd32f10x_hw.c types.h
  group Doc
    ./source/: readme.txt
  group CMSIS
    ../../GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group GD32F10x_Peripherals
    ../../GD32F10x_Firmware_Library/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group GD32F10x_EVAL
    ../../EVAL_Library/Utilities/: gd32f107c_eval.c
  group Startup
    ../../GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_cl.s
  group drivers
    ./source/drivers/: gpio.c gpio.h systick.c systick.h activity.c activity.h system.c system.h spi.c spi.h
  group USB_Drivers
    ../../GD32F10x_Firmware_Library/GD32F10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
    ./source/: usb_conf.h usbd_conf.h
  group USB_Device
    ../../GD32F10x_Firmware_Library/GD32F10x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
    ./source/usb/libd/: usb_device.c usb_device.h
  group HID
    ./source/usb/libd/hid/: usb_class_conf.h usb_desc.c usb_customhid.c usb_customhid.h
  group CDC
    ./source/usb/libd/cdc/: usb_cdc.c usb_cdc.h usb_class_conf.h usb_desc.c
  group Keyboard
    ./source/usb/libd/keyboard/: usb_class_conf.h usb_keyboardhid.c usb_keyboardhid.h usb_desc.c
